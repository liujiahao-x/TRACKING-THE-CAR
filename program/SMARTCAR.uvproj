# Keil uVision project SMARTCAR.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: SMARTCAR +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Headfile
  group Source Group 1
    ./: main.c uart.c servo.c sensor.c delay.c
